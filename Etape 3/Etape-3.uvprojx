# Keil uVision project Etape-3.uvprojx, settings and files
target Simu (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CHTI +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: .\GASSP72
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Sources
    ./Src/: principal.c signal_synthetique.asm trigo.asm f17p30_f18p135.asm
    ./: calcul_dft.s
    ./Tests/: f1p-45.asm f23p-26_f24p-116.asm
  group Sys
    ./Src/: startup-rvds.s
  group Driver
    ./GASSP72/: gassp72.lib
software components: CMSIS:CORE 4.3.0
